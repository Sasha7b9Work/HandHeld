# Keil uVision project DeviceEnergy.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: GD32E230, DEBUG
  c include: ..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;.\src\Hardware\HAL;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group src
    ./src/: defines.h main.cpp Device.cpp Device.h opt.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h Vibrato.cpp Vibrato.h Power.cpp Power.h DeepSleep.cpp DeepSleep.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: gd32e23x_it.h gd32e23x_libopt.h systick.h HAL_PINS.cpp HAL_PINS.h HAL.cpp HAL.h HAL_I2C.cpp gd32e23x_it.cpp systick.cpp HAL_ADC.cpp HAL_TIM2.cpp HAL_ROM.cpp HAL_TIM5.cpp
  group Display
    ./src/Display/: Display.cpp Display.h Colors.cpp Colors.h Icons.cpp Icons.h
  group Display/Font
    ./src/Display/: Display.h
    ./src/Display/Font/: Font.cpp Font.h font5.inc font8.inc font10_7.inc
  group Keyboard
    ./src/Keyboard/: Keyboard.h Keyboard.cpp
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h Menu.txt MenuItemDef.h
  group Menu/Pages
    ./src/Menu/Pages/: Pages.h PageAlarm.cpp PageJournal.cpp PageWatch.cpp Pages.cpp
  group Modules/Beeper
    ./src/Modules/Beeper/: Beeper.cpp Beeper.h driverBeeper.cpp driverBeeper.h
  group Modules/Beeper/Sounds
    ./src/Modules/Beeper/Sounds/: sound1.h sound2.h sound3.h
  group Modules/CMT2210AW
    ./src/Modules/CMT2210AW/: CMT2210AW.cpp CMT2210AW.h
  group Modules/LED
    ./src/Modules/LED/: driverLED.cpp driverLED.h LED.cpp LED.h
  group Modules/PCF8563
    ./src/Modules/PCF8563/: PCF8563.cpp PCF8563.h PCF8563_gd.cpp
  group Modules/ST7735
    ./src/Modules/ST7735/: ST7735.h ST7735.cpp
  group PlayerMIDI
    ./src/PlayerMIDI/: BeeperMIDI.cpp BeeperMIDI.h PlayerConfigMIDI.h PlayerMIDI.cpp PlayerMIDI.h
  group PlayerMIDI/Melodies
    ./src/PlayerMIDI/Melodies/: melody1.cpp melody1.h melody2.cpp melody2.h melody3.cpp melody3.h melody4.cpp melody4.h melody5.cpp melody5.h melody6.cpp melody6.h melody7.cpp melody7.h melody8.cpp melody8.h melody9.cpp melody9.h melody10.cpp melody10.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h Source.cpp Source.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h
  group Utils
    ./src/Utils/: Math.cpp Math.h FPS.cpp FPS.h StringUtils.cpp StringUtils.h
target Release (6180000::V6.18::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: Project
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: GD32E230
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
